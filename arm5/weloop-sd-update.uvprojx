# Keil uVision project weloop-sd-update.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;C:\nrf51_sdk_v5_2_0\nrf51822\Include;C:\nrf51_sdk_v5_2_0\nrf51822\Include\app_common;C:\nrf51_sdk_v5_2_0\nrf51822\Include\ble;C:\nrf51_sdk_v5_2_0\nrf51822\Include\ble\ble_services;C:\nrf51_sdk_v5_2_0\nrf51822\Include\s110;C:\nrf51_sdk_v5_2_0\nrf51822\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0x24000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/ble/ble_services/: ble_srv_common.c
    ../: ble_nus.c
  group Libraries
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/ble/: ble_advdata.c ble_conn_params.c
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/sd_common/: softdevice_handler.c
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/simple_uart/: simple_uart.c
    C:/nrf51_sdk_v5_2_0/nrf51822/Source/app_common/: app_timer.c
